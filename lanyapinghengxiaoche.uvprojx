# Keil uVision project lanyapinghengxiaoche.uvprojx, settings and files
target Blance_Car (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blance_Car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Source\FreeRTOS\include;.\Source\Libraries\CMSIS;.\Source\Libraries\FWlib\inc;.\Source\User\6050DMP;.\Source\User\bsp_usart1;.\Source\User\DATASCOPE;.\Source\User;.\Source\FreeRTOS\portable\RVDS\ARM_CM3;.\Source\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./Source/User/: main.c stm32f10x_it.c afx_math.c motor.c radio.c general_link.c pid_countrol.c speed_.c
    ./Source/User/6050DMP/: anbt_dmp_driver.c anbt_dmp_mpu6050.c anbt_i2c.c
    ./Source/User/bsp_usart1/: bsp_usart1.c
    ./Source/User/DATASCOPE/: DataScope_DP.C
  group CORE
    ./Source/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./Source/Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./Source/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./Source/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Source/FreeRTOS/portable/MemMang/: heap_4.c
    ./Source/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group DRIVER
    ./Source/driver/: encoder.c pwm_out.c serial.c
software components: CMSIS:CORE 5.3.0
